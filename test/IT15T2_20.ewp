# IAR project IT15T2_20.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1765 NXP LPC1765
  ICCARM.CCDefines: SONY_DRIVER_BUILD_OPTION_CXD2843; SONY_INTEG_DISABLE_ASCOT_TUNER; SONY_DISABLE_I2C_REPEATER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: RTOS_common\include\; RTOS_HAL\; include\; LPCUSB; demod\include; demod\cxd2843; demod\cxd2843\dvb_cable; demod\cxd2843\dvb_terr; demod\cxd2843\i2c; demod\cxd2843\lib; demod\cxd2843\tuner; demod\cxd2843_lolev; drv; sys; msg_global; lib; dev; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: IT15T2_20.srec
  ILINK.IlinkOutputFile: IT15T2_20.out
  ILINK.IlinkIcfFile: tm-1000_main.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SONY_DRIVER_BUILD_OPTION_CXD2843; SONY_INTEG_DISABLE_ASCOT_TUNER; SONY_DISABLE_I2C_REPEATER
  ICCARM.CCIncludePath2: RTOS_common\include\; RTOS_HAL\; include\; LPCUSB; demod\include; demod\cxd2843; demod\cxd2843\dvb_cable; demod\cxd2843\dvb_terr; demod\cxd2843\i2c; demod\cxd2843\lib; demod\cxd2843\tuner; demod\cxd2843_lolev
  OBJCOPY.OOCOutputFile: IT15T2_20.bin
  group (top)
    ./: ADC.c Battery.c Calibr.c Comm.c ConfigModes.c cstartup_M.s Demod.c dglock.c DvbMeas.c FaultsTrace.c FManager.c glcd.c hwInit.c I2C.c keyboard.c Measure.c Memory.c menu.c Notebook.c PcOperate.c Preparation.c PrintScreen.c Routines.c Serial.c SPI.c Stend.c t2plp_menu.c tm-1000.c Tuner.c TvSystem.c VM.c
  group charger
    charger/: charger.c
  group config
    ./: tm-1000_main.icf
  group demod
    demod/: demod_cir.c demod_ex.c demod_iqbuf.c demod_iqmer.c demod_meas.c demod_meas_c.c demod_meas_c2.c demod_meas_t.c demod_meas_t2.c t2_bitrate.c t2_plp.c
  group demod/cxd2843
    demod/cxd2843/: sony_common.c sony_demod.c sony_integ.c sony_stopwatch_port.c
  group demod/cxd2843/cable
    demod/cxd2843/dvb_cable/: sony_demod_dvbc.c sony_demod_dvbc2.c sony_demod_dvbc2_adv_monitor.c sony_demod_dvbc2_monitor.c sony_demod_dvbc_adv_monitor.c sony_demod_dvbc_monitor.c sony_integ_dvbc.c sony_integ_dvbc2.c
  group demod/cxd2843/i2c
    demod/cxd2843/i2c/: sony_i2c.c
  group demod/cxd2843/lib
    demod/cxd2843/lib/: sony_math.c
  group demod/cxd2843/terr
    demod/cxd2843/dvb_terr/: sony_demod_dvbt.c sony_demod_dvbt2.c sony_demod_dvbt2_adv_monitor.c sony_demod_dvbt2_monitor.c sony_demod_dvbt_adv_monitor.c sony_demod_dvbt_monitor.c sony_integ_dvbt_t2.c
  group demod/cxd2843_lolev
    demod/cxd2843_lolev/: demod_api.c demod_inst.c i2c_lolev.c tuner_ctrl.c
  group dev/tv
    dev/tv/: test.c tvrcv.c
  group dev/tv/tvhw
    dev/tv/tvhw/: tvhw.c
  group dev/tv/tvhw/cfg
    dev/tv/tvhw/cfg/: tda10025_cfg.c tda18275_cfg.c
  group dev/tv/tvlev
    dev/tv/tvlev/: tvlev.c
  group drv/lpc1766
    drv/lpc1766/: core_lowlevel.c
  group dvbinfo
    dvbinfo/: dvbinfo.c dvbinfo_c.c dvbinfo_t.c dvbinfo_t2.c
  group itpub/dev/pubdev/rfmeas
    itpub/dev/pubdev/rfmeas/: rfmeas.c
  group itpub/dev/pubdev/tvrcv
    itpub/dev/pubdev/tvrcv/: pub_tvrcv.c
  group lclz
    lclz/: lclz.c
  group lib/appevent
    lib/appevent/: appevent.c
  group lib/array
    lib/array/: array.c
  group lib/gui_lng
    lib/gui_lng/: strloc.c
  group lib/sort
    lib/sort/: al_sort.c
  group lib/syspanel
    lib/syspanel/: syspanel.c
  group lib/tv
    lib/sort/: moving_average.c
    lib/tv/: tv.c tv_unit_common.c
  group lnb
    lnb/: lnb.c
  group msg_global
    msg_global/: msg_global.c
  group pwroff
    pwroff/: pwroff.c
  group RTOS_common
    RTOS_common/: croutine.c heap_3.c list.c queue.c tasks.c
  group RTOS_HAL
    RTOS_HAL/: port.c portasm.s
  group statistic
    statistic/: rfstat.c
  group statistic/model/trace
    statistic/model/trace/: trace_impl.c
  group statistic/model/trace/analog
    statistic/model/trace/analog/: analog.c
  group statistic/model/trace/common
    statistic/model/trace/common/: common.c
  group statistic/model/trace/dig
    statistic/model/trace/dig/: dig.c
  group statistic/model/trace/dvb
    statistic/model/trace/dvb/: dvb.c
  group statistic/model/trace/utils
    statistic/model/trace/utils/: config.c convert.c int_trap.c interval_data.c modcfg.c observer.c second_trace.c seconds_buf.c tracepar.c
  group statistic/model/unit
    statistic/model/unit/: unit_impl.c
  group statistic/msg_statistic
    statistic/msg/: msg_statistic.c
  group statistic/utils
    statistic/utils/: accum.c empty_data.c lnb_checker.c sign.c
  group statistic/utils/error_msg
    statistic/utils/error_msg/: error_msg.c
  group statistic/utils/observer
    statistic/utils/observer/: observer_impl.c
  group statistic/utils/unit
    statistic/utils/unit/: unit.c
  group stend
    stend/: sto_ctrl.c
  group sys
    sys/: al_lng.c general_rtn.c syslang.c
  group USB
    LPCUSB/: dyndescr.c USB_CDC.c usbcontrol.c usbhw_lpc.c usbinit.c usbstdreq.c
